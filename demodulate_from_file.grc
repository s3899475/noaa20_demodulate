options:
  parameters:
    author: Christopher Tait
    generate_options: qt_gui
    id: noaa20_hrd_demodulate
    output_language: python
    title: NOAA 20 Demodulation
  states: {}

blocks:
- name: dqpsk
  id: variable_constellation
  parameters:
    precision: '8'
    type: dqpsk
  states: {}
- name: loop_bw
  id: variable
  parameters:
    value: '0.002'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '25_000_000'
  states: {}
- name: sps
  id: variable
  parameters:
    value: samp_rate/sym_rate
  states: {}
- name: sym_rate
  id: variable
  parameters:
    value: '15_000_000'
  states: {}
- name: sync_bw
  id: variable
  parameters:
    value: '0.004368'
  states: {}
- name: syncword_cc_enc
  id: variable
  parameters:
    value: '[0x56, 0xe4, 0x5e, 0x57, 0xa6, 0x68, 0x75, 0x46]'
  states: {}
- name: syncword_mod
  id: variable
  parameters:
    value: digital.generic_mod(dqpsk, False, 2, True, 0.35, False, False)
  states: {}
- name: syncword_sym
  id: variable_modulate_vector
  parameters:
    data: syncword_cc_enc
    mod: syncword_mod
    taps: '[1]'
  states: {}
- name: analog_agc_xx_0
  id: analog_agc_xx
  parameters:
    gain: '1.0'
    max_gain: '65536'
    rate: '1e-2'
    reference: '1.0'
    type: complex
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /home/chris/Code/noaa20_demodulate/out/corr.bin
    type: byte
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/chris/Code/noaa20_demodulate/recordings/2025-02-14_05-36-00_25000000SPS_1200000000Hz-NOAA20.cs16
    offset: '2_000_000_000'
    repeat: 'False'
    type: short
  states: {}
- name: blocks_interleaved_short_to_complex_0
  id: blocks_interleaved_short_to_complex
  parameters:
    scale_factor: 2**15
    vector_input: 'False'
  states: {}
- name: blocks_tag_debug_0
  id: blocks_tag_debug
  parameters:
    name: corr tag
    type: complex
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_uchar_to_float_0
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: digital_constellation_soft_decoder_cf_0
  id: digital_constellation_soft_decoder_cf
  parameters:
    constellation: dqpsk
  states: {}
- name: digital_corr_est_cc_0
  id: digital_corr_est_cc
  parameters:
    mark_delay: '1'
    sps: '2'
    symbols: syncword_sym
    threshold: '0.2'
    threshold_method: digital.THRESHOLD_ABSOLUTE
  states: {}
- name: digital_costas_loop_cc_0
  id: digital_costas_loop_cc
  parameters:
    order: '4'
    w: loop_bw
  states: {}
- name: digital_symbol_sync_xx_0
  id: digital_symbol_sync_xx
  parameters:
    constellation: dqpsk
    damping: '1'
    loop_bw: sync_bw
    max_dev: 0.005*sps
    osps: '2'
    resamp_type: digital.IR_MMSE_8TAP
    sps: sps
    ted_gain: '1'
    ted_type: digital.TED_MOD_MUELLER_AND_MULLER
    type: cc
  states: {}
- name: pdu_pdu_to_tagged_stream_0
  id: pdu_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    gui_hint: 0,1,1,1
    name: '"After PLL"'
    size: '1024'
    type: complex
  states: {}
- name: qtgui_const_sink_x_1
  id: qtgui_const_sink_x
  parameters:
    gui_hint: 0,0,1,1
    name: '"Before PLL"'
    size: '1024'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    gui_hint: 1, 0, 1, 2
    name: '"Output Packets"'
    size: 1024*10
    srate: samp_rate
    type: float
    ymax: '255'
    ymin: '0'
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '2'
    fbw: '0.4'
    interp: '1'
    type: ccc
  states: {}
- name: root_raised_cosine_filter_0
  id: root_raised_cosine_filter
  parameters:
    alpha: '0.5'
    decim: '1'
    gain: '1'
    ntaps: '31'
    samp_rate: samp_rate
    sym_rate: sym_rate
    type: fir_filter_ccf
  states: {}
- name: satellites_ccsds_concatenated_deframer_0
  id: satellites_ccsds_concatenated_deframer
  parameters:
    convolutional: '"CCSDS"'
    frame_size: '892'
    precoding: '"differential"'
    rs_basis: '"dual"'
    rs_interleaving: '4'
    scrambler: '"CCSDS"'
    threshold: '4'
  states: {}
- name: snippet_0
  id: snippet
  parameters:
    section: main_after_init
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: '2'
  states: {}
- name: virtual_sink_1
  id: virtual_sink
  parameters:
    stream_id: '1'
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: '2'
  states: {}
- name: virtual_source_1
  id: virtual_source
  parameters:
    stream_id: '1'
  states: {}

connections:
- [analog_agc_xx_0, '0', root_raised_cosine_filter_0, '0']
- [blocks_file_source_0, '0', blocks_interleaved_short_to_complex_0, '0']
- [blocks_interleaved_short_to_complex_0, '0', blocks_throttle_0, '0']
- [blocks_throttle_0, '0', analog_agc_xx_0, '0']
- [blocks_uchar_to_float_0, '0', qtgui_time_sink_x_0, '0']
- [digital_constellation_soft_decoder_cf_0, '0', satellites_ccsds_concatenated_deframer_0, '0']
- [digital_corr_est_cc_0, '0', blocks_tag_debug_0, '0']
- [digital_corr_est_cc_0, '0', rational_resampler_xxx_0, '0']
- [digital_costas_loop_cc_0, '0', qtgui_const_sink_x_0, '0']
- [digital_costas_loop_cc_0, '0', virtual_sink_0, '0']
- [digital_symbol_sync_xx_0, '0', digital_corr_est_cc_0, '0']
- [digital_symbol_sync_xx_0, '0', qtgui_const_sink_x_1, '0']
- [pdu_pdu_to_tagged_stream_0, '0', blocks_file_sink_0, '0']
- [pdu_pdu_to_tagged_stream_0, '0', blocks_uchar_to_float_0, '0']
- [rational_resampler_xxx_0, '0', digital_costas_loop_cc_0, '0']
- [root_raised_cosine_filter_0, '0', virtual_sink_1, '0']
- [satellites_ccsds_concatenated_deframer_0, out, pdu_pdu_to_tagged_stream_0, pdus]
- [virtual_source_0, '0', digital_constellation_soft_decoder_cf_0, '0']
- [virtual_source_1, '0', digital_symbol_sync_xx_0, '0']

metadata:
  file_format: 1
